# SRCREV = "${AUTOREV}"
# SRC_URI:remove = "git://github.com/JeffyCN/xorg-xserver;protocol=https;nobranch=1;branch=${PV}_2025_11_06;"
# SRC_URI:append = " git://github.com/JeffyCN/xorg-xserver;protocol=https;nobranch=1;branch=21.1.21_2025_11_06;"

